# Keil uVision project Cosmic_IOT.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32G030F6Px STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Cosmic_IOT +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\Gen;..\base\ComIf\src;..\base\Flash\src;..\base\Helpers\Buffer\src;..\base\Helpers\String\src;..\base\SIMCOM\src;..\base\SysOS\src;..\Cosmic_App\MQTT;..\Cosmic_App\MQTT\src;..\project;..\STM32_Driver;..\base\ComIf\api;..\base\Flash\api;..\base\Helpers\Buffer\api;..\base\Helpers\String\api;..\base\SIMCOM\api;..\base\SysOS\api;..\Cosmic_App\MQTT\api
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group base
    ../base/ComIf/src/: ComIf.c ComIf_CalcChecksum.c ComIf_RxIndication.c ComIf_RxRequest.c ComIf_Transmit.c ComIf_TxShadowBuffer.c
    ../base/Helpers/Buffer/src/: Buffer.c
    ../base/Helpers/String/src/: StringHelper.c
    ../base/SIMCOM/src/: SIMCOM.c SIMCOM_Clock.c SIMCOM_State.c SIMCOM_Message.c SIMCOM_MQTT.c SIMCOM_MQTT_Publish.c SIMCOM_MQTT_SSL.c SIMCOM_Calls.c
    ../base/SysOS/src/: SysOS.c
  group Cosmic_App
    ../Cosmic_App/: AvrStatusMessageHandling.c CS_Iot.c MQTT_Application.c Message_App.c
  group Gen
    ../Gen/: Buffer_Config.c ComIf_Config.c SysOs_Processes.c
  group project
    ./: main.c
  group STM32_Driver
    ../STM32_Driver/: GPIO_Driver.c PLL_Driver.c UART_Driver.c Systick_Interrupt.c
    ../base/Flash/src/: Flash_EEPROM.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.4.0
